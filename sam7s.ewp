# IAR project sam7s.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCIncludePath2: uC OS-II\; include\; include\bsp\; include\drive\; drive\include\; task\include\; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: uC OS-II\; include\; include\bsp\; include\drive\
  OBJCOPY.OOCOutputFile: sam7s.srec
  ILINK.IlinkOutputFile: ucos.hex
  ILINK.IlinkIcfFile: F:\工作\GSMS\软件\settings\at91SAM7S64_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    app/: main.c
    ./: os.c
  group APP
    app/: alarm.c gsm.c mc.c monitor.c set.c
  group Drive
    Drive/: button.c buzz.c flash.c flash_w25x16.c led.c rs232.c spi.c twc.c
  group Drive/BSP
    BSP/: bsp.c cpu.c
  group Drive/Timer
    Drive/timer/: AT91SAM7S_Time.c time.c
  group TASK
    task/src/: efs.c phe.c sio.c
  group uC/OS-II
    uC OS-II/: os_core.c os_cpu_a.asm os_cpu_c.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
